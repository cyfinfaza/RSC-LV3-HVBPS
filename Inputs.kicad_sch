File: Inputs.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: updated pinout, begin layout
